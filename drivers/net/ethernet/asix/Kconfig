## drivers/net/ethernet/asix/Kconfig
```kconfig
config AX88796DT
	tristate "AX88796 devicetree support"
	depends on AX88796
	---help---
	  ax88796 devicetree wrapper
```
